# Keil uVision project f042_t1.uvprojx, settings and files
target f042_t1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F042K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: f042_t1
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c include: ../Inc;     ../Drivers/STM32F0xx_HAL_Driver/Inc;     ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;     ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_adc.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_adc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c gpio.c adc.c stm32f0xx_it.c usart.c dma.c crc.c stm32f0xx_hal_msp.c
software components: CMSIS:CORE 5.0.2, Compiler:I/O:STDOUT 1.2.1
